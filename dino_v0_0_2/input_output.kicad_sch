File: dino_v0_0_2/input_output.kicad_sch (KiCad schematic)
At the start: 26 parts, among them SW1 SW_DIP_x08

Commit message: v0.3.0 - Rev 1.2.0 Update
Other:
- title: Dino v0.0.2 -> Dino v0.0.3
